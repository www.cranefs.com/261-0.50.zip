# Autodesk Inventor part: 261-0.a50
## iProperties
Created: 2007-07
Part Number: 261-0.a50
Document SubType Name: Modeling
Designer: btaylor
Density: 1 g/cm^3
Author: btaylor
